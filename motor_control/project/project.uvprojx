# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\project;..\stm32f1x_fwlib\inc;..\system\delay;..\system\sys;..\system\usart;..\hardware\led;..\hardware\pwm;..\hardware\motor;..\hardware\Servo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group fwlib
    ../stm32f1x_fwlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c
  group sys
    ../system/delay/: delay.c
    ../system/usart/: usart.c
    ../system/sys/: sys.c
  group hardware
    ../hardware/led/: led.c
    ../hardware/pwm/: pwm.c
    ../hardware/motor/: motor.c
    ../hardware/Servo/: servo.c
